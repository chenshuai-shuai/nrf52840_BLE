# Keil uVision project My_System.uvprojx, settings and files
target TMP119_EVM_V10 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: My_System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\System_Config;..\CORE;..\User;..\prj;..\APP;..\HW\I2C;..\HW\UART1;..\HW\TMP119
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group System
    ../User/: delay.c
    ../System_Config/: stm32f4xx_it.c System_Config.c system_stm32f4xx.c
  group HW
    ../HW/I2C/: F40x_I2C.c
    ../HW/UART1/: F40x_UART1.c
  group APP
    ../APP/: _MAIN.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group TMP119
    ../HW/TMP119/: TMP119_EVM.c
  group ReadMe
    ../ReadMe/: 使用说明.txt
