# Keil uVision project My_System.uvprojx, settings and files
target TMP119_EVM_V1.0 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My_System +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\ANT-TB-F103-V10;..\Hardware\LED;..\Hardware\KEY;..\TFT;..\APP;..\Hardware\TIM3;..\Hardware\I2C;..\Hardware\TMP119;..\Hardware\UART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group System
    ../ANT-TB-F103-V10/: Board_Driver.c
  group Hardware
    ../Hardware/LED/: F10x_Led.c
    ../Hardware/KEY/: F10x_Key.c
    ../Hardware/TIM3/: F10x_TIM3.c
    ../Hardware/UART1/: F10x_UART1.c
  group 1.14IPS TFT
    ../TFT/: TFT_Driver.c TFT_IO.c
  group I2C
    ../Hardware/I2C/: ANT_I2C.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_usart.c stm32f10x_tim.c
  group app
    ../APP/: app.c
  group TMP119
    ../Hardware/TMP119/: TMP119_EVM.c
  group ReadMe
    ../ReadMe/: 使用说明.txt
